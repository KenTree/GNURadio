options:
  parameters:
    generate_options: qt_gui
    id: PythonBlock
    output_language: python
    title: Add, Subtract Flowgraph
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 0.5+0.5j
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: customModule_addSubSelect_0
  id: customModule_addSubSelect
  parameters:
    selector: 'False'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', customModule_addSubSelect_0, '1']
- [analog_sig_source_x_0, '0', customModule_addSubSelect_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [customModule_addSubSelect_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
