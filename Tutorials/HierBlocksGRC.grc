options:
  parameters:
    generate_options: qt_gui
    id: HierBlocksGRC
    output_language: python
    title: Hier Blocks
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: FrequencyChange_0
  id: FrequencyChange
  parameters:
    samp_rate: samp_rate
  states: {}
- name: FrequencyShifter_0
  id: FrequencyShifter
  parameters:
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [FrequencyChange_0, '0', blocks_throttle2_0_0, '0']
- [FrequencyShifter_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', FrequencyChange_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', FrequencyShifter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
