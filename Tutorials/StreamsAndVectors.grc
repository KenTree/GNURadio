options:
  parameters:
    generate_options: qt_gui
    id: samplePointsGRC
    output_language: python
    title: Streams and Vecors
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_streams_1
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal Source A"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal Source B"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Interleaved Signal Sources"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Interleaved Signal Sources"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_streams_to_vector_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_streams_to_vector_1, '1']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_streams_to_vector_1, '0', blocks_vector_to_stream_1, '0']
- [blocks_streams_to_vector_1, '0', blocks_vector_to_streams_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_vector_to_streams_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_1, '1', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
